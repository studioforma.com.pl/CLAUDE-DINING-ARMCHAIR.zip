Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Claude-Dining Armchair - ver4.ifc
Time: 2025-11-02T23:48:39
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (3)
Name
 | Claude-Dining Armchair_0 - ObjectType: SketchupGroup
 | Claude-Dining Armchair_1 - ObjectType: SketchupGroup
 | Claude-Dining Armchair_2 - ObjectType: SketchupGroup
